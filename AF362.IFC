Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: AF362.IFC
Time: 2022-01-06T03:54:18
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 302-01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-02N
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 302-06
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-07
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-08_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-10-A
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 302-10-B
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 302-10_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 302-11N
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-12N_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 302-13_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
